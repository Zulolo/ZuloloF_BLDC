# Keil uVision project Zulolo_F_Force.uvprojx, settings and files
target BLDC_driver (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: Mini54ZDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Power +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: CLK_APBCLK_ACMP_EN_Pos=CLK_APBCLK_CMP_EN_Pos,FOR_CAR
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\Mini51Series\Include;..\..\..\Library\StdDriver\inc;.\StdDriver\inc;.\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --map --first='startup_Mini51Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group User
    ./User/: main.c BLDCSensorLess.c Communication.c it.c Error.c Protection.c
software components: CMSIS:CORE 5.0.2, Device:StartupConfig 8.14.1, Device:Driver:ACMP 3.01.002, Device:Driver:ADC 3.01.002, Device:Driver:CLK 3.01.002, Device:Driver:FMC 3.01.002, Device:Driver:GPIO 3.01.002, Device:Driver:I2C 3.01.002, Device:Driver:PWM 3.01.002, Device:Driver:SPI 3.01.002, Device:Driver:SYS 3.01.002, Device:Driver:Timer 3.01.002, Device:Driver:UART 3.01.002, Device:Driver:WDT 3.01.002, Device:Startup 3.01.002
